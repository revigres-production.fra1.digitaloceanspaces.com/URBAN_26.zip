Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 4da3498d-abdf-40c2-892f-26c179844a68, NumberOfSaves: 100], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Architecture]
Time: 2026-06-12T17:25:09+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-ANTRACITE, Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-ANTRACITE:14093
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 31211248U1; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211248U1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36 -ANTRACITE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemENovo: Sim; ItemEParcialmenteReciclado: 0.29; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- ANTRACITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-BONE, Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-BONE:21505
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 312112X671
Type - Pset_EnvironmentalImpactIndicators - Reference: 312112X671
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-BONE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- BONE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-CRAFT, Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-CRAFT:21527
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 31211224T1
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211224T1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-CRAFT
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.19; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- CRAFT; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-FOG, Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-FOG:21549
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 31211221T1
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211221T1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-FOG
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- FOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-GRIS, Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-GRIS:21571
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 31211222T1
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211222T1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-GRIS
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- GRIS; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-OFFWHITE, Basic Wall:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-OFFWHITE:21593
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 31211223T1
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211223T1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat); Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-ANTRACITE, Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-ANTRACITE:18907
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36 -ANTRACITE
Type - Pset_CoveringCommon - Reference: 31211248U1; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211248U1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.29; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- ANTRACITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-BONE, Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-BONE:21508
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-BONE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 312112X671
Type - Pset_EnvironmentalImpactIndicators - Reference: 312112X671
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- BONE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-CRAFT, Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-CRAFT:21530
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-CRAFT
Type - Pset_CoveringCommon - IsExternal: no; Reference: 31211224T1
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211224T1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.19; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- CRAFT; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-FOG, Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-FOG:21552
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-FOG
Type - Pset_CoveringCommon - IsExternal: no; Reference: 31211221T1
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211221T1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- FOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-GRIS, Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-GRIS:21574
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-GRIS
Type - Pset_CoveringCommon - IsExternal: no; Reference: 31211222T1
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211222T1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- GRIS; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-OFFWHITE, Floor:REVIGRES-URBAN-DECOR-29.5X29.5-RECT-STRATUS 36-OFFWHITE:21596
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DECOR-30X30-RECT-STRATUS 36-OFFWHITE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 31211223T1
Type - Pset_EnvironmentalImpactIndicators - Reference: 31211223T1
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 29.5 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DECOR-29.5X29.5-RECT- OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
