Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 714e52dc-8bfa-45d0-b8f3-670da77b0550, NumberOfSaves: 6], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Architecture]
Time: 2026-06-12T17:35:41+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-ANTRACITE, REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-ANTRACITE:21202
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-ANTRACITE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-ANTRACITE
Pset_CoveringCommon - Reference: 30X60-RECT-ANTRACITE
Pset_EnvironmentalImpactIndicators - Reference: 30X60-RECT-ANTRACITE
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-URBAN-DG CF CANTO -30X60-RECT-URBAN ANTRACITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; PesoLiquido: 0; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ClassificacaoFogo: 0 mm; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 8.5 mm; ComprimentoNominal: 295 mm; LarguraNominal: 592 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0.29; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-BONE, REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-BONE:21223
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-BONE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-BONE
Pset_CoveringCommon - Reference: 30X60-RECT-BONE
Pset_EnvironmentalImpactIndicators - Reference: 30X60-RECT-BONE
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-URBAN-DG CF CANTO -30X60-RECT-URBAN BONE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 8.5 mm; ComprimentoNominal: 295 mm; LarguraNominal: 592 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemEParcialmenteReciclado: 0.03; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-CRAFT, REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-CRAFT:21231
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-CRAFT
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-CRAFT
Pset_CoveringCommon - Reference: 30X60-RECT-CRAFT
Pset_EnvironmentalImpactIndicators - Reference: 30X60-RECT-CRAFT
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-URBAN-DG CF CANTO -30X60-RECT-URBAN CRAFT; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 8.5 mm; ComprimentoNominal: 295 mm; LarguraNominal: 592 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemEParcialmenteReciclado: 0.19; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-FOG, REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-FOG:21239
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-FOG
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-FOG
Pset_CoveringCommon - Reference: 30X60-RECT-FOG
Pset_EnvironmentalImpactIndicators - Reference: 30X60-RECT-FOG
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-URBAN-DG CF CANTO -30X60-RECT-URBAN FOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 8.5 mm; ComprimentoNominal: 295 mm; LarguraNominal: 592 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemEParcialmenteReciclado: 0.23; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-GRIS, REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-GRIS:21247
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-GRIS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-GRIS
Pset_CoveringCommon - Reference: 30X60-RECT-GRIS
Pset_EnvironmentalImpactIndicators - Reference: 30X60-RECT-GRIS
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-URBAN-DG CF CANTO -30X60-RECT-URBAN GRIS; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 8.5 mm; ComprimentoNominal: 295 mm; LarguraNominal: 592 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemEParcialmenteReciclado: 0.23; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-OFFWHITE, REVIGRES-URBAN-DGCF CANTO DIREITO-R23-v02:30X60-RECT-OFFWHITE:21255
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-OFFWHITE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-URBAN-30C60-DGCF DIREITO-RECT-OFFWHITE
Pset_CoveringCommon - Reference: 30X60-RECT-OFFWHITE
Pset_EnvironmentalImpactIndicators - Reference: 30X60-RECT-OFFWHITE
IFC.REVIGRES-Dados gerais-Generic Model - Nome: REVIGRES-URBAN-DG CF CANTO -30X60-RECT-URBAN OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 8.5 mm; ComprimentoNominal: 295 mm; LarguraNominal: 592 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemEParcialmenteReciclado: 0.03; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
