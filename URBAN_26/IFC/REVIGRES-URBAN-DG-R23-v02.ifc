Properties of the parts of a building model (IFC4), part 1 of 4

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: f80439bd-5031-4cf5-99c6-483cda69656a, NumberOfSaves: 191], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Architecture]
Time: 2026-06-12T17:24:48+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X120-RECT-ANTRACITE, Floor:REVIGRES-URBAN-DG-30X120-RECT-ANTRACITE:189410
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X120-RECT-ANTRACITE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X120-RECT-ANTRACITE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X120-RECT-ANTRACITE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 295 mm; LarguraNominal: 1186 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.29; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X120-RECT-URBAN ANTRACITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X120-RECT-BONE, Floor:REVIGRES-URBAN-DG-30X120-RECT-BONE:189651
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X120-RECT-BONE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X120-RECT-BONE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X120-RECT-BONE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 295 mm; LarguraNominal: 1186 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X120-RECT-URBAN BONE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X120-RECT-CRAFT, Floor:REVIGRES-URBAN-DG-30X120-RECT-CRAFT:189748
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X120-RECT-CRAFT
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X120-RECT-CRAFT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X120-RECT-CRAFT
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 295 mm; LarguraNominal: 1186 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.19; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X120-RECT-URBAN CRAFT; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X120-RECT-FOG, Floor:REVIGRES-URBAN-DG-30X120-RECT-FOG:189864
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X120-RECT-FOG
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X120-RECT-FOG
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X120-RECT-FOG
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 295 mm; LarguraNominal: 1186 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X120-RECT-URBAN FOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X120-RECT-GRIS, Floor:REVIGRES-URBAN-DG-30X120-RECT-GRIS:189987
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X120-RECT-GRIS
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X120-RECT-GRIS
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X120-RECT-GRIS
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 295 mm; LarguraNominal: 1186 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X120-RECT-URBAN GRIS; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X120-RECT-OFFWHITE, Floor:REVIGRES-URBAN-DG-30X120-RECT-OFFWHITE:190182
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X120-RECT-OFFWHITE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X120-RECT-OFFWHITE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X120-RECT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 295 mm; LarguraNominal: 1186 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X120-RECT-URBAN OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-NAT-ANTRACITE, Floor:REVIGRES-URBAN-DG-30X30-NAT-ANTRACITE:189327
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-NAT-ANTRACITE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-NAT-ANTRACITE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-NAT-ANTRACITE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: NAT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 30 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.29; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-NAT-URBAN ANTRACITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-NAT-BONE, Floor:REVIGRES-URBAN-DG-30X30-NAT-BONE:189630
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-NAT-BONE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-NAT-BONE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-NAT-BONE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: NAT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 30 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-NAT-URBAN BONE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-NAT-CRAFT, Floor:REVIGRES-URBAN-DG-30X30-NAT-CRAFT:189727
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-NAT-CRAFT
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-NAT-CRAFT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-NAT-CRAFT
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: NAT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 30 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.19; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-NAT-URBAN CRAFT; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-NAT-FOG, Floor:REVIGRES-URBAN-DG-30X30-NAT-FOG:189843
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-NAT-FOG
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-NAT-FOG
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-NAT-FOG
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: NAT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 30 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-NAT-URBAN FOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-NAT-GRIS, Floor:REVIGRES-URBAN-DG-30X30-NAT-GRIS:189966
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-NAT-GRIS
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-NAT-GRIS
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-NAT-GRIS
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: NAT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 30 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-NAT-URBAN GRIS; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-NAT-OFFWHITE, Floor:REVIGRES-URBAN-DG-30X30-NAT-OFFWHITE:190161
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-NAT-OFFWHITE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-NAT-OFFWHITE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-NAT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: NAT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 2000 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 30 mm; LarguraNominal: 30 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-NAT-URBAN OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-RECT-ANTRACITE, Floor:REVIGRES-URBAN-DG-30X30-RECT-ANTRACITE:152336
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-RECT-ANTRACITE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-RECT-ANTRACITE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-RECT-ANTRACITE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 295 mm; LarguraNominal: 295 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - ItemENovo: Sim; ItemEParcialmenteReciclado: 0.29; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-RECT-URBAN ANTRACITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-RECT-BONE, Floor:REVIGRES-URBAN-DG-30X30-RECT-BONE:189623
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-RECT-BONE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-RECT-BONE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-RECT-BONE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 295 mm; LarguraNominal: 295 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-RECT-URBAN BONE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-RECT-CRAFT, Floor:REVIGRES-URBAN-DG-30X30-RECT-CRAFT:189720
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-RECT-CRAFT
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-RECT-CRAFT
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-RECT-CRAFT
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 295 mm; LarguraNominal: 295 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.19; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-RECT-URBAN CRAFT; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-RECT-FOG, Floor:REVIGRES-URBAN-DG-30X30-RECT-FOG:189836
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-RECT-FOG
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-RECT-FOG
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-RECT-FOG
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 295 mm; LarguraNominal: 295 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-RECT-URBAN FOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-RECT-GRIS, Floor:REVIGRES-URBAN-DG-30X30-RECT-GRIS:189959
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-RECT-GRIS
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-RECT-GRIS
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-RECT-GRIS
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 295 mm; LarguraNominal: 295 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-RECT-URBAN GRIS; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X30-RECT-OFFWHITE, Floor:REVIGRES-URBAN-DG-30X30-RECT-OFFWHITE:190154
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X30-RECT-OFFWHITE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X30-RECT-OFFWHITE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X30-RECT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 1500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 2; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 7.7 mm; ComprimentoNominal: 295 mm; LarguraNominal: 295 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.03; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-URBAN-DG-30X30-RECT-URBAN OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-URBAN-DG-30X60-NAT-ANTRACITE, Floor:REVIGRES-URBAN-DG-30X60-NAT-ANTRACITE:189368
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-URBAN-DG-30X60-NAT-ANTRACITE
Type - Pset_CoveringCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
Pset_CoveringCommon - Reference: REVIGRES-URBAN-DG-30X60-NAT-ANTRACITE
Pset_EnvironmentalImpactIndicators - Reference: REVIGRES-URBAN-DG-30X60-NAT-ANTRACITE
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Urban; Acabamento: NAT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/urban; PaisOrigem: Portugal
